# Keil uVision project example_task2.uvprojx, settings and files
target example_task2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: example_task2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../bsp;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../UCOSIII/Config;../UCOSIII/uC-CPU;../UCOSIII/uC-CPU/ARM;../UCOSIII/uC-LIB;../UCOSIII/uC-OS3;../UCOSIII/uC-OS3/Ports;../UCOSIII/uC-OS3/Ports/ARM
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP/AHT20
    ../bsp/: aht20.c aht20.h
  group uC/CPU
    ../UCOSIII/uC-CPU/: cpu_core.c cpu_c.c
    ../UCOSIII/uC-CPU/ARM/: cpu_a.asm
  group uC/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Source
    ../UCOSIII/uC-OS3/: os_core.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cfg_app.c
  group uC/OS-III Ports
    ../UCOSIII/uC-OS3/Ports/: os_cpu_c.c
    ../UCOSIII/uC-OS3/Ports/ARM/: os_cpu_a.asm
  group bsp
    ../bsp/: my_main.c my_main.h
software components: CMSIS:CORE 4.3.0
